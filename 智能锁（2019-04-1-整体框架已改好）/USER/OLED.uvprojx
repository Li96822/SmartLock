# Keil uVision project OLED.uvprojx, settings and files
target OLED (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEYBOARD;..\HARDWARE\OLED;..\HARDWARE\FLASH;..\HARDWARE\BREAK;..\HARDWARE\NFC;..\HARDWARE\USART3;..\HARDWARE\AS608;..\HARDWARE\KEY;..\HARDWARE\TIME;..\HARDWARE\L620;..\HARDWARE\RTC;..\HARDWARE\ID1016B;..\HARDWARE\UART4;..\HARDWARE\peizhi;..\HARDWARE\WKUP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/FLASH/: stmflash.c
    ../HARDWARE/BREAK/: break.c
    ../HARDWARE/NFC/: nfc.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/KEYBOARD/: key.c
    ../HARDWARE/KEY/: button.c
    ../HARDWARE/AS608/: as608.c
    ../HARDWARE/TIME/: time.c
    ../HARDWARE/L620/: L620.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/UART4/: uart4.c
    ../HARDWARE/ID1016B/: id1016b.c
    ../HARDWARE/WKUP/: wkup.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_exti.c
  group README
    ../: README.TXT
